# Repository DF4IAH/HFT-Core-Module (continued)

## EAGLE design CAD/Eagle/HFT-Core-Module_1V1.brd (continued)

Schematic: HFT-Core-Module_1V1.sch, sheet 15, I2C1 - VCTCXO

Parts:
C1501, C1511, C1512, C1531, C1541, C1543: 100nF; C0402
C1522: 1uF; C0402
C1532: 100pF; C0402
C1542: 1nF; C0402
R1521: 100kR; R0402
R1531: 10kR; R0402
R1538, R1539, R1541: 47R; R0402
R1542: 1MR; R0402
R1543: 33kR; R0402
U1501: LM4120IM5-3.0; SOT95P285X120-5N
U1511: MAX5217; µMAX8
U1531: CFPT-141-20MHZ; CFPT-141
U1541: OPA354; SOT-23-5
U1542: LPV811; SOT-23-5

Connections:
20MHZ_DAC_OUT: R1521.1, U1511.6 (OUT)
20MHZ_XO: R1538.1, U1531.3 (OUT), U1541.3 (+IN)
20MHZ_XON: R1539.2; also elsewhere on the board
20MHZ_XOP: R1538.2; also elsewhere on the board
+3V0_20MHZ_VCTCXO: C1511.1, C1531.1, U1501.5 (VOUT), U1511.1 (REF), U1531.4 (VCC_3V0)
+3V3: C1543.1, U1542.5 (V+); also elsewhere on the board
+3V3_XO: C1501.1, C1512.1, U1501.3 (EN), U1501.4 (VIN), U1511.5 (!AUX), U1511.7 (VDD); also elsewhere on the board
+3V3_XO_PA: C1541.1, U1541.5 (V+); also elsewhere on the board
AD_VCTCXO1: R1543.1, U1542.1 (OUT), U1542.4 (-IN)
GND: C1501.2, C1511.2, C1512.2, C1522.2, C1531.2, C1532.2, C1541.2, C1542.2, C1543.2, R1539.1, U1501.2 (GND), U1511.2 (ADDR), U1511.8 (GND), U1531.2 (GND), U1541.2 (V-), U1542.2 (V-); also elsewhere on the board
I2C1_SCL: U1511.3 (SCL); also elsewhere on the board
I2C1_SDA: U1511.4 (SDA); also elsewhere on the board
PA1: R1543.2; also elsewhere on the board
VCTCXO_PA_N: C1542.1, R1542.1, U1541.4 (-IN)
VCTCXO_PA_O: R1541.1, R1542.2, U1541.1 (OUT)
XO_LP: C1522.1, R1521.2, R1531.1, U1542.3 (+IN)
XO_OUT: R1541.2; also elsewhere on the board
XO_VC: C1532.1, R1531.2, U1531.1 (VC)

Notes on the sheet:
f_LP = 10 Hz
Use ECS VC-TXO-23SM-200-B 1:Vcon 2:GND 3:Out 4:VDD
Impedance 100 Ohms
High prec. LDO
MOS-OPs
VCTCXO
D/A-Converter: I2C addr: 0x38
MCU_ADC1_IN6_XO_PULL
VCTCXO 20MHz (XO)
Iq=80uA
Iq=1.5mA
Iq=0.45uA
Iq=4.9mA
Iq=1.5mA+160uA

Schematic: HFT-Core-Module_1V1.sch, sheet 16, I2C1 - PLL Si5338

Parts:
C1601, C1604: 220nF; C0402
C1602, C1603, C1605: 100nF; C0402
C1615, C1616: 10nF; C0402
R1623, R1631, R1632, R1643, R1644, R1651: 47R; R0402
R1661: N/A; R0402
TP_IN_CLK1, TP_IN_CLK2: PTR1B1,27; B1,27
U1601: Si5338; QFN24_P0MM5_CTRPAD
U1651: TS5A23166; R-PDSO-G8

Connections:
20MHZ_XON: C1616.1, R1661.1; also elsewhere on the board
20MHZ_XOP: C1615.1, R1661.2; also elsewhere on the board
+3V3_HICUR: C1601.1, C1602.1, C1603.1, C1604.1, C1605.2, U1601.7 (VDD), U1601.11 (VDDO3), U1601.15 (VDDO2), U1601.16 (VDDO1), U1601.20 (VDDO0), U1601.24 (VDD); also elsewhere on the board
AX_8MHZ: U1601.4 (IN4); also elsewhere on the board
CLK0_N: R1643.2; also elsewhere on the board
CLK0_P: R1644.2; also elsewhere on the board
CLK2_N: R1631.2; also elsewhere on the board
CLK2_P: R1632.2; also elsewhere on the board
CLK_AUDIO_ADC: R1623.1; also elsewhere on the board
GND: C1601.2, C1602.2, C1603.2, C1604.2, C1605.1, U1601.23 (RSVD_GND), U1601.25 (PAD), U1651.4; also elsewhere on the board
I2C1_SCL: U1601.12 (SCL); also elsewhere on the board
I2C1_SDA: U1601.19 (SDA); also elsewhere on the board
MCU_HSE_R: R1651.2, U1651.2, U1651.5
PA8: U1601.3 (IN3); also elsewhere on the board
PC9: U1601.8 (INTR); also elsewhere on the board
PEXPA_P0_6_R: U1651.3; also elsewhere on the board
PEXPA_P0_7_R: U1651.7; also elsewhere on the board
PEXPA_P1_7_R: U1651.8; also elsewhere on the board
PH0: R1651.1; also elsewhere on the board
SI5338_CLK0A: R1644.1, U1601.22 (CLK0A)
SI5338_CLK0B: R1643.1, U1601.21 (CLK0B)
SI5338_CLK2A: R1632.1, U1601.14 (CLK2A)
SI5338_CLK2B: R1631.1, U1601.13 (CLK2B)
SI5338_CLK3A: U1601.10 (CLK3A), U1651.1
SI5338_CLK3B: R1623.2, U1601.9 (CLK3B)
SI5338_IN5: C1615.2, U1601.5 (IN5)
SI5338_IN6: C1616.2, U1601.6 (IN6)
SI5338_IN_CLK1_R: TP_IN_CLK1.TP, U1601.1 (IN1)
SI5338_IN_CLK2_R: TP_IN_CLK2.TP, U1601.2 (IN2)
XO_OUT: U1651.6; also elsewhere on the board

Notes on the sheet:
Impedance 100 Ohms
Clock distributor I2C addr: 0x70
8MHz
20MHz
MCU_EXTI9_SI5338
10MHz
MCU_MCO
Si5338 PLL
MCU_HSE
SW_PWR
Iq=0.01uA
Iq=45mA
HSE_XO_SW_EN
HSE_PLL_SW_EN
D.C.

Schematic: HFT-Core-Module_1V1.sch, sheet 17, I2C1 - I2S audio ADC

Parts:
C1701, C1704, C1711, C1721: 10uF; C0402
C1702, C1703, C1705: 100nF; C0402
C1706: 2.2uF; C0402
C1712, C1722: 10nF; C0402
L1701: 10uH; L0603
R1711, R1721: 10kR; R0402
R1712, R1722: 100R; R0402
R1751, R1752, R1753, R1761: 47R; R0402
U1701: PCM1863; R-PDSO-G30

Connections:
+3V3_HICUR: C1701.1, C1702.1, L1701.2, U1701.13 (DVDD), U1701.14 (IOVDD); also elsewhere on the board
AUDIOADC_AVDD: C1703.2, L1701.1, U1701.8 (AVDD)
AUDIOADC_BCK: R1752.1, U1701.17 (BCK)
AUDIOADC_DOUT: R1751.1, U1701.18 (DOUT)
AUDIOADC_INTA: R1761.1, U1701.21 (GPIO1/INTA/DMIN)
AUDIOADC_LDO: C1704.1, C1705.1, U1701.11 (LDO)
AUDIOADC_LRCK: R1753.1, U1701.16 (LRCK)
AUDIOADC_VINL1: C1712.1, R1712.2, U1701.3 (VINL1/VIN1P)
AUDIOADC_VINL1_R: C1711.2, R1712.1
AUDIOADC_VINR1: C1722.1, R1722.2, U1701.4 (VINR1/VIN2P)
AUDIOADC_VINR1_R: C1721.2, R1722.1
AUDIOADC_VREF: C1706.1, U1701.6 (VREF)
AUDIO_IN_L: C1711.1, R1711.2; also elsewhere on the board
AUDIO_IN_R: C1721.1, R1721.2; also elsewhere on the board
CLK_AUDIO_ADC: U1701.15 (SCKI); also elsewhere on the board
GND: C1701.2, C1702.2, C1703.1, C1704.2, C1705.2, C1706.2, C1712.2, C1722.2, R1711.1, R1721.1, U1701.7 (AGND), U1701.12 (DGND), U1701.25 (MS/AD), U1701.26 (MD0); also elsewhere on the board
I2C1_SCL: U1701.24 (MC/SCL); also elsewhere on the board
I2C1_SDA: U1701.23 (MOSI/SDA); also elsewhere on the board
PB13: R1752.2; also elsewhere on the board
PD2: R1761.2; also elsewhere on the board
PD11: R1751.2; also elsewhere on the board
PD12: R1753.2; also elsewhere on the board

Notes on the sheet:
I2S audio stereo A/D-Converter I2C addr: 0x4A
10MHz
MCU_EXTI2_AUDIO_ADC
I2S audio ADC
D.C.
MCU_I2S2A_SD_IN
MCU_I2S2A_SCK_IN
MCU_I2S2A_FS_IN
Iq=0.12mA

Schematic: HFT-Core-Module_1V1.sch, sheet 18, I2C1 - I2S audio DAC

Parts:
C1801, C1802: 4.7uF; C0402
C1803: 2.2uF; C0402
C1811, C1812: 1uF; C0402
C1831, C1841: 2.7nF; C0402
L1801: 10uH; L0603
R1811, R1812: 0R; R0402
R1821, R1822, R1823, R1824: 47R; R0402
R1831, R1841: 560R; R0402
U1801: WM8523; TSSOP20

Connections:
+3V3_HICUR: C1801.1, L1801.2, U1801.6 (LINEVDD); also elsewhere on the board
AUDIO_DAC_A0: R1811.2, U1801.15 (!CS!/!MUTE)
AUDIO_DAC_A1: R1812.2, U1801.12 (SDOUT/DEEMPH)
AUDIO_DAC_AVDD: C1802.2, L1801.1, U1801.19 (AVDD)
AUDIO_DAC_BCLK: R1822.2, U1801.10 (BCLK)
AUDIO_DAC_CPCA: C1811.1, U1801.5 (CPCA)
AUDIO_DAC_CPCB: C1811.2, U1801.3 (CPCB)
AUDIO_DAC_CPVOUTN: C1812.2, U1801.2 (CPVOUTN)
AUDIO_DAC_DACDAT: R1821.2, U1801.8 (DACDAT)
AUDIO_DAC_LINEVOUTL: R1831.1, U1801.1 (LINEVOUTL)
AUDIO_DAC_LINEVOUTR: R1841.1, U1801.20 (LINEVOUTR)
AUDIO_DAC_LRCLK: R1823.2, U1801.9 (LRCLK)
AUDIO_DAC_MCLK: R1824.2, U1801.11 (MCLK)
AUDIO_DAC_VMID: C1803.2, U1801.18 (VMID)
AUDIO_OUT_L: C1831.1, R1831.2; also elsewhere on the board
AUDIO_OUT_R: C1841.1, R1841.2; also elsewhere on the board
GND: C1801.2, C1802.1, C1803.1, C1812.1, C1831.2, C1841.2, R1811.1, R1812.1, U1801.4 (LINEGND), U1801.16 (CIFMODE), U1801.17 (AGND); also elsewhere on the board
I2C1_SCL: U1801.14 (SCLK/AIFMODE1); also elsewhere on the board
I2C1_SDA: U1801.13 (SDA/AIFMODE0); also elsewhere on the board
PE3: R1821.1; also elsewhere on the board
PE8: R1822.1; also elsewhere on the board
PE9: R1823.1; also elsewhere on the board
PE10: R1824.1; also elsewhere on the board
PEXPB_P0_4_R: U1801.7 (ZFLAG); also elsewhere on the board

Notes on the sheet:
I2S audio stereo D/A-Converter I2C addr: 0x1A
I2S audio DAC
MCU_I2S1B_SD_OUT
MCU_I2S1B_SCK_OUT
MCU_I2S1B_FS_OUT
MCU_I2S1B_MCLK_OUT
AUDIO_DAC_ZFLAG
Load: 10kR
Iq=1.9mA
Package: 0603mil

Schematic: HFT-Core-Module_1V1.sch, sheet 19, UART1 - SIM868 GSM/GPRS/GNSS

Parts:
C1901: 47pF; C0402
C1902: 100nF; C0402
C1903: 10nF; C0402
C1904: 10uF; C0402
C1951, C1955: 220nF; C0402
C1952, C1953, C1954: 22pF; C0402
C1961: 1uF; C0402
D1901: CMAD6001; SOD923
D1902: MMSZ4690-E3-08 (5.6V); SOD123
R1901, R1942: 10kR; R0402
R1941: NTC 10kR; R0402
R1943, R1944: 4.7kR; R0402
R1951, R1952, R1953: 47R; R0402
R1961, R1962: 22R; R0402
U1901: SIM868
X1951: MICROSIM-8P_SDCARD-8P_MOLEX-104642-1610
X1961: HEADER-2X2; 2X02

Connections:
GND: C1901.1, C1902.1, C1903.1, C1904.1, C1951.2, C1952.1, C1953.1, C1954.1, C1955.2, C1961.1, D1902.A, R1941.1, U1901.8 (VSS), U1901.13 (VSS), U1901.19 (VSS), U1901.21 (VSS), U1901.27 (VSS), U1901.30 (VSS), U1901.31 (VSS), U1901.33 (VSS), U1901.36 (VSS), U1901.37 (VSS), U1901.45 (VSS), U1901.63 (VSS), U1901.66 (VSS), U1901.67 (VSS), U1901.69 (VSS), U1901.70 (VSS), U1901.71 (VSS), U1901.72 (VSS), U1901.73 (VSS), U1901.74 (VSS), U1901.75 (VSS), U1901.76 (VSS), U1901.77 (VSS), X1951.S5, X1951.T6, X1961.1; also elsewhere on the board
LIPO_SYS: C1901.2, C1902.2, C1904.2, D1902.C, U1901.34 (GPS_VBAT), U1901.35 (VBAT); also elsewhere on the board
MCU_VBAT: D1901.A; also elsewhere on the board
MC_SW: X1951.SW
S6: X1951.S6
SC_2: R1951.2, X1951.S2
SC_3: R1952.2, X1951.S3
SC_7: R1953.1, X1951.S7
SIM_1PPS: U1901.60 (GNSS_1PPS); also elsewhere on the board
SIM_!PWRKEY: U1901.39 (PWRKEY); also elsewhere on the board
SIM_ADC: R1941.2, R1942.1, U1901.38 (ADC)
SIM_BT_ANT: U1901.20 (BT_ANT); also elsewhere on the board
SIM_GNSS_EN: R1901.2, U1901.59 (GNSS_EN)
SIM_GPIO1: R1901.1, U1901.57 (GPIO1)
SIM_GPIO2: U1901.58 (GPIO2)
SIM_GPS_ANT: U1901.68 (GPS_ANT); also elsewhere on the board
SIM_GPS_RXD: U1901.22 (UART2_TXD), U1901.62 (GPS_RXD)
SIM_GPS_TXD: U1901.23 (UART2_RXD), U1901.61 (GPS_TXD)
SIM_GSM_ANT: U1901.32 (GSM_ANT); also elsewhere on the board
SIM_MCCA0: U1901.49 (MCCA0), X1951.T7
SIM_MCCA1: U1901.48 (MCCA1), X1951.T8
SIM_MCCA2: U1901.47 (MCCA2), X1951.T1
SIM_MCCA3: U1901.46 (MCCA3), X1951.T2
SIM_MCCCK: U1901.50 (MCCCK), X1951.T5
SIM_MCCM0: U1901.51 (MCCM0), X1951.T3
SIM_MICN: U1901.10 (MICN)
SIM_MICP: U1901.9 (MICP)
SIM_NETLIGHT: U1901.41 (NETLIGHT); also elsewhere on the board
SIM_RF_SYNC: U1901.29 (RF_SYNC); also elsewhere on the board
SIM_SCL: R1944.1, U1901.65 (SCL)
SIM_SDA: R1943.1, U1901.64 (SDA)
SIM_SIM1_CLK: C1953.2, R1952.1, U1901.16 (SIM1_CLK)
SIM_SIM1_DATA: C1954.2, R1953.2, U1901.15 (SIM1_DATA)
SIM_SIM1_DET: U1901.14 (SIM1_DET)
SIM_SIM1_RST: C1952.2, R1951.1, U1901.17 (SIM1_RST)
SIM_SIM1_VDD: C1951.1, U1901.18 (SIM1_VDD), X1951.S1
SIM_SIM2_CLK: U1901.54 (SIM2_CLK)
SIM_SIM2_DATA: U1901.53 (SIM2_DATA)
SIM_SIM2_DET: U1901.52 (SIM2_DET)
SIM_SIM2_RST: U1901.55 (SIM2_RST)
SIM_SIM2_VDD: U1901.56 (SIM2_VDD)
SIM_SPK1N: U1901.12 (SPK1N)
SIM_SPK1P: U1901.11 (SPK1P)
SIM_SPK2N: U1901.43 (SPK2N)
SIM_SPK2P: U1901.44 (SPK2P)
SIM_STATUS: U1901.42 (STATUS); also elsewhere on the board
SIM_UART1_CTS: U1901.4 (UART1_CTS); also elsewhere on the board
SIM_UART1_DCD: U1901.5 (UART1_DCD); also elsewhere on the board
SIM_UART1_DTR: U1901.6 (UART1_DTR); also elsewhere on the board
SIM_UART1_RI: U1901.7 (UART1_RI); also elsewhere on the board
SIM_UART1_RTS: U1901.3 (UART1_RTS); also elsewhere on the board
SIM_UART1_RXD: U1901.2 (UART1_RXD); also elsewhere on the board
SIM_UART1_TXD: U1901.1 (UART1_TXD); also elsewhere on the board
SIM_USBCON_DM: R1961.2, X1961.4
SIM_USBCON_DP: R1962.2, X1961.2
SIM_USB_DM: R1961.1, U1901.26 (USB_DM)
SIM_USB_DP: R1962.1, U1901.25 (USB_DP)
SIM_USB_VBUS: C1961.2, U1901.24 (USB_VBUS), X1961.3
SIM_VDD_EXT: C1955.1, R1942.2, R1943.2, R1944.2, U1901.40 (VDD_EXT), X1951.T4
SIM_VRTC: C1903.2, D1901.C, U1901.28 (VRTC)

Notes on the sheet:
SIM868 GSM/GPRS/GNSS
SIMcard holder
SIM USB
Vpp: N/A

Schematic: HFT-Core-Module_1V1.sch, sheet 20, SIM868 Level-Shifter A

Parts:
R2011, R2012, R2013, R2014, R2015, R2016, R2017, R2018: 1kR; R0402

Connections:
PA6: R2012.2; also elsewhere on the board
PC0: R2018.2; also elsewhere on the board
PC7: R2014.2; also elsewhere on the board
PEXPB_P1_2_R: R2016.2; also elsewhere on the board
PEXPB_P1_3_R: R2017.2; also elsewhere on the board
PF9: R2015.2; also elsewhere on the board
PG6: R2013.2; also elsewhere on the board
PG8: R2011.2; also elsewhere on the board
SIM_1PPS: R2015.1; also elsewhere on the board
SIM_NETLIGHT: R2017.1; also elsewhere on the board
SIM_RF_SYNC: R2018.1; also elsewhere on the board
SIM_STATUS: R2016.1; also elsewhere on the board
SIM_UART1_CTS: R2012.1; also elsewhere on the board
SIM_UART1_DCD: R2014.1; also elsewhere on the board
SIM_UART1_RI: R2013.1; also elsewhere on the board
SIM_UART1_TXD: R2011.1; also elsewhere on the board

Notes on the sheet:
Level-Shifter A removed (2.8V --> 3.3V)
SIM868 Level-Shifter A
MCU_LPUART_RX_IN (Pull-Down)
MCU_LPUART_CTS_IN (Pull-Down)
MCU_LPUART_RI_IN (Pull-Down)
MCU_LPUART_DCD_IN (Pull-Down)
MCU_TIMCAP_1PPS (Pull-Down)
Direction --->
MCU_RF_SYNC_IN (Pull-Down)

Schematic: HFT-Core-Module_1V1.sch, sheet 21, SIM868 Level-Shifter B

Parts:
R2111, R2112, R2113, R2114: 1kR; R0402
R2121, R2122, R2123, R2124: 5.6kR; R0402

Connections:
GND: R2121.1, R2122.1, R2123.1, R2124.1; also elsewhere on the board
PA2: R2112.2; also elsewhere on the board
PB1: R2113.2; also elsewhere on the board
PEXPB_P1_1_R: R2111.2; also elsewhere on the board
PG7: R2114.2; also elsewhere on the board
SIM_!PWRKEY: R2111.1, R2121.2; also elsewhere on the board
SIM_UART1_DTR: R2114.1, R2124.2; also elsewhere on the board
SIM_UART1_RTS: R2113.1, R2123.2; also elsewhere on the board
SIM_UART1_RXD: R2112.1, R2122.2; also elsewhere on the board

Notes on the sheet:
Level-Shifter B simplified (2.8V <-- 3.3V)
SIM868 Level-Shifter B
<--- Direction
MCU_LPUART_TX_OUT
MCU_LPUART_RTS_OUT
MCU_LPUART_DTR_OUT

Schematic: HFT-Core-Module_1V1.sch, sheet 22, SPI3 - VHF/UHF SX1262 - ch 1

Parts:
C2201: 10uF; C0402
C2202, C2271: 100nF; C0402
C2203: 470nF; C0402
C2204: 47pF; C0402
C2205: 47nF; C0402
C2263, C2282, C2283: 3.3pF; C0402
C2264, C2281: 39pF; C0402
C2265, C2293: 0pF; C0402
C2266: 5.6pF; C0402
C2267: 2.2pF; C0402
C2272: 1nF; C0402
C2291: 1.8pF; C0402
C2292: 2.4pF; C0402
L2201: 15uH; L_3.00MM_X_3.00MM
L2261: 0R; L0603
L2262: 47nH; L0603
L2263: 2.5nH; L0603
L2264: 4.7nH; L0603
L2282: 9.1nH; L0603
L2291: 15nH; L0603
Q2211: ABM3B-32.0000MHZ; ABM3B
R2211, R2221, R2224, R2251, R2252, R2253: 47R; R0402
TP_SX_DIO1, TP_SX_DIO2, TP_SX_DIO3: PTR1TP06R; TP06R
U2201: SX1262; QFN24-4X4-0P5-PAD
U2271: PE4259; SC-70_6-LEAD_2X1MM25_0P65

Connections:
+3V3: C2201.1, C2202.1, C2271.1, U2201.1 (VDD_IN), U2201.10 (VBAT), U2201.11 (VBAT_IO), U2271.6 (VDD_!CTRL); also elsewhere on the board
CH1_ANT: C2283.2, L2282.1; also elsewhere on the board
GND: C2201.2, C2202.2, C2203.2, C2204.2, C2205.2, C2265.1, C2266.2, C2267.2, C2271.2, C2272.2, C2282.1, C2283.1, C2291.1, C2293.1, Q2211.2 (3), Q2211.4 (3), U2201.2 (VSS), U2201.5 (VSS), U2201.8 (VSS), U2201.20 (VSS), U2201.25 (VSS), U2271.2 (GND); also elsewhere on the board
MCU_SPI3_MOSI: U2201.17 (MOSI); also elsewhere on the board
MCU_SPI3_SCK: U2201.18 (SCLK); also elsewhere on the board
MCU_SX_SEL_OUT: R2221.2, U2201.19 (NSS)
PC11: R2224.1; also elsewhere on the board
PD8: R2211.1; also elsewhere on the board
PEXPA_P1_6_R: U2201.15 (NRESET); also elsewhere on the board
PE_RFC: C2281.1, U2271.5 (RFC)
PE_RFC_2: C2281.2, C2282.2, L2282.2
PF12: C2272.1, R2252.2, U2271.4 (CTRL); also elsewhere on the board
PF15: R2221.1; also elsewhere on the board
PG0: R2253.2; also elsewhere on the board
PG1: R2251.2; also elsewhere on the board
SX_BUSY: R2211.2, U2201.14 (BUSY)
SX_DCC_SW: L2201.1, U2201.9 (DCC_SW)
SX_DIO1: R2253.1, TP_SX_DIO1.TP, U2201.13 (DIO1)
SX_DIO2: R2252.1, TP_SX_DIO2.TP, U2201.12 (DIO2)
SX_DIO3: R2251.1, TP_SX_DIO3.TP, U2201.6 (DIO3)
SX_MISO: R2224.2, U2201.16 (MISO)
SX_RFI_2: C2292.2, C2293.2, U2271.3 (RF2)
SX_RFI_N: C2292.1, L2291.1, U2201.22 (RFI_N)
SX_RFI_P: C2291.2, L2291.2, U2201.21 (RFI_P)
SX_RFO: L2261.2, U2201.23 (RFO)
SX_RFO_2: C2263.1, C2265.2, L2261.1, L2262.1, L2263.2
SX_RFO_3: C2263.2, C2264.1, C2266.1, L2263.1
SX_RFO_4: C2264.2, L2264.2
SX_RFO_5: C2267.1, L2264.1, U2271.1 (RF1)
SX_VREG: C2203.1, L2201.2, U2201.7 (VREG)
SX_VR_PA: C2204.1, C2205.1, L2262.2, U2201.24 (VR_PA)
SX_XTA: Q2211.1, U2201.3 (XTA)
SX_XTB: Q2211.3 (2), U2201.4 (XTB)

Notes on the sheet:
VHF / UHF SX1262 - channel 1 SPI
MCU_SPI3_MISO
SX_NRESET
SX1262 UHF TRX (ch1)
MCU_SX_BUSY_IN
MCU_EXTI12_SX_DIO2_TXRXSW
MCU_EXTI1_SX_DIO3_TIMEOUT
MCU_EXTI0_SX_DIO1_TXRXDONE
Iq=1.2uA
Package: 0805mil

Schematic: HFT-Core-Module_1V1.sch, sheet 23, SPI3 - VHF/UHF AX5243 - ch 2

Parts:
C2301, C2302, C2303: 100nF; C0402
C2312, C2313, C2316: N/A; C0402
C2314, C2315: 4.3pF; C0402
C2317, C2318, C2321, C2322, C2323: 4.7pF; C0402
L2311, L2316, L2317, L2321: 22nH; L0603
L2312, L2313: 100nH; L0603
L2314, L2315: 43nH; L0603
Q2311: ABM3B-16.0000MHZ; ABM3B
R2321, R2341, R2351, R2391: 47R; R0402
R2331, R2332: 100kR; R0402
TP_AX_ADC1, TP_AX_ADC2: PTR1TP06R; TP06R
TP_AX_IRQ: PTR1TP06R; TP06R
TP_AX_TCXO_EN: PTR1TP06R; TP06R
U2301: AX5243; QFN20-4X4-0P5-PAD

Connections:
+3V3: C2301.1, U2301.16 (VDD_IO); also elsewhere on the board
AX_8MHZ: R2321.2; also elsewhere on the board
AX_ADC1: R2331.1, TP_AX_ADC1.TP, U2301.17 (GPADC1)
AX_ADC2: R2332.1, TP_AX_ADC2.TP, U2301.18 (GPADC2)
AX_ANTN: C2313.1, C2315.1, L2313.1, U2301.4 (ANTN)
AX_ANTP: C2312.1, C2314.1, L2312.1, U2301.3 (ANTP)
AX_B1: C2317.1, L2314.2, L2317.1
AX_B2: C2316.1, C2318.1, L2315.2, L2316.2
AX_CLK16A: Q2311.1, U2301.20 (CLK16P)
AX_CLK16B: Q2311.3 (2), U2301.19 (CLK16N)
AX_COMB: C2318.2, C2321.1, C2322.1, L2317.2, L2321.1
AX_IRQ: R2351.2, TP_AX_IRQ.TP, U2301.14 (IRQ)
AX_L1: L2311.1, U2301.8 (L1)
AX_L2: L2311.2, U2301.7 (L2)
AX_SYSCLK: R2321.1, U2301.9 (SYSCLK)
AX_T1: C2314.2, L2314.1
AX_T2: C2315.2, L2315.1
AX_VDD1: C2302.2, U2301.1 (VDD_ANA)
AX_VDD5: C2303.2, U2301.5 (VDD_ANA)
CH2_ANT: C2321.2, C2323.1, L2321.2; also elsewhere on the board
GND: C2301.2, C2302.1, C2303.1, C2312.2, C2313.2, C2316.2, C2317.2, C2322.2, C2323.2, L2312.2, L2313.2, L2316.1, Q2311.2 (3), Q2311.4 (3), R2331.2, R2332.2, U2301.2 (GND), U2301.21 (GND); also elsewhere on the board
MCU_AX_MISO: R2341.2, U2301.12 (MISO)
MCU_AX_SEL_OUT: R2391.2, U2301.10 (SEL)
MCU_SPI3_MOSI: U2301.13 (MOSI); also elsewhere on the board
MCU_SPI3_SCK: U2301.11 (CLK); also elsewhere on the board
PC11: R2341.1; also elsewhere on the board
PE7: R2351.1; also elsewhere on the board
PEXPB_P0_5_R: TP_AX_TCXO_EN.TP, U2301.15 (TCXO_EN); also elsewhere on the board
PF14: R2391.1; also elsewhere on the board

Notes on the sheet:
VHF / UHF AX5243 - channel 2 SPI
MCU_EXTI7_AX
AX5243 UHF TRX (ch2)
AX_GPIO1_TCXO_EN
Iq=0.5uA
D.C.

Schematic: HFT-Core-Module_1V1.sch, sheet 24, 12V Down-Converter

Parts:
C2401, C2402, C2403: 10uF; C0402
C2404: 10nF; C0402
C2405: 3.3uF; C0402
C2411: 0.47uF; C0402
C2412: 100nF; C0402
C2421, C2422, C2423: 22uF; C0402
L2411: 2.2uH; L_6.00MM_X_6.00MM
R2411: 3R; R0402
U2401: LM53603-Q1; HTSSOP16
X2411: WIRE-TO-BOARD_5MM08_1X02

Connections:
DC_12V_IN: C2401.1, C2402.1, C2403.1, C2404.1, U2401.11 (EN), U2401.12 (VIN), U2401.13 (VIN), X2411.1
GND: C2401.2, C2402.2, C2403.2, C2404.2, C2405.1, C2412.2, C2421.2, C2422.2, C2423.2, U2401.6 (SYNC), U2401.7 (FPWM), U2401.10 (AGND), U2401.15 (PGND), U2401.16 (PGND), U2401.PAD (EP), U2401.PAD1 (EP), U2401.PAD2 (EP), U2401.PAD3 (EP), U2401.PAD4 (EP), U2401.PAD5 (EP), U2401.PAD6 (EP), U2401.PAD7 (EP), U2401.PAD8 (EP), U2401.PAD9 (EP), U2401.PAD10 (EP), U2401.PAD11 (EP), U2401.PAD12 (EP), U2401.PAD13 (EP), X2411.2; also elsewhere on the board
LM53603_!RESET: U2401.8 (!RESET)
LM53603_BIAS: C2412.1, R2411.1, U2401.5 (BIAS)
LM53603_CBOOT: C2411.2, U2401.3 (CBOOT)
LM53603_SW: C2411.1, L2411.2, U2401.1 (SW), U2401.2 (SW)
LM53603_VCC: C2405.2, U2401.4 (VCC)
POW_IN_5V0: C2421.1, C2422.1, C2423.1, L2411.1, R2411.2, U2401.9 (FB); also elsewhere on the board

Notes on the sheet:
12V --> 5V0 Down-Converter
12V Down-Converter
Iq=24uA
Abracon ASPI-6045S-2R2N-T 6.00mm x 6.00mm
D.C.

Schematic: HFT-Core-Module_1V1.sch, sheet 25, I2C1 - LiPo charger

Parts:
C2501, C2504, C2505, C2511: 10uF; C0402
C2502, C2521: 1uF; C0402
C2503: 47nF; C0402
C2541: 100nF; C0402
D2521: CRS08; SOD80C
L2501: 2.2uH; L_6.00MM_X_6.00MM
R2501: 240R; R0402
R2511: 2.27kR; R0402
R2512: 6.86kR; R0402
R2521: 0R; R0402
R2541: 33kR; R0402
R2554: 47R; R0402
TP_LIPO_BAT: PTR1B1,27; B1,27
TP_LIPO_CUR: PTR1B1,27; B1,27
TP_LIPO_SYS: PTR1B1,27; B1,27
U2501: BQ24193; VQFN-24
U2541: LPV811; SOT-23-5
X2551: JST_S3B-XH-A

Connections:
+3V3: C2541.1, U2541.5 (V+); also elsewhere on the board
+5V0: C2521.2, D2521.C, R2521.2, U2501.1 (VBUS), U2501.24 (VBUS); also elsewhere on the board
GND: C2501.2, C2502.2, C2504.2, C2505.2, C2511.2, C2521.1, C2541.2, R2501.1, R2512.2, U2501.9 (!CE), U2501.17 (PGND), U2501.18 (PGND), U2501.25 (PGND), U2501.26 (PGND), U2501.P$1 (PGND), U2501.P$2 (PGND), U2501.P$3 (PGND), U2501.P$4 (PGND), U2501.P$5 (PGND), U2541.2 (V-), X2551.3; also elsewhere on the board
I2C1_SCL: U2501.5 (SCL); also elsewhere on the board
I2C1_SDA: U2501.6 (SDA); also elsewhere on the board
LIPO_ADC_CUR_IN_LOOP: R2541.2, U2541.1 (OUT), U2541.4 (-IN)
LIPO_BAT: C2511.1, TP_LIPO_BAT.TP, U2501.13 (BAT), U2501.14 (BAT), X2551.1
LIPO_BTST: C2503.1, U2501.21 (BTST)
LIPO_ILIM: R2501.2, U2501.10 (ILIM), U2541.3 (+IN)
LIPO_INT: R2554.2, U2501.7 (INT)
LIPO_PMID: C2501.1, U2501.23 (PMID)
LIPO_REGN: C2502.1, R2511.2, U2501.22 (REGN)
LIPO_SW: C2503.2, L2501.2, U2501.19 (SW), U2501.20 (SW)
LIPO_SYS: C2504.1, C2505.1, L2501.1, TP_LIPO_SYS.TP, U2501.15 (SYS), U2501.16 (SYS); also elsewhere on the board
LIPO_TS12: R2511.1, R2512.1, U2501.11 (TS1), U2501.12 (TS2), X2551.2
PA3: R2541.1, TP_LIPO_CUR.TP; also elsewhere on the board
PA5: R2554.1; also elsewhere on the board
PEXPA_P1_3_R: U2501.2 (PSEL); also elsewhere on the board
PEXPA_P1_4_R: U2501.8 (OTG); also elsewhere on the board
PEXPB_P0_2_R: U2501.4 (STAT); also elsewhere on the board
PEXPB_P0_3_R: U2501.3 (!PG); also elsewhere on the board
POW_IN_5V0: D2521.A; also elsewhere on the board
VUSB_SW: R2521.1; also elsewhere on the board

Notes on the sheet:
LiPo charger (nom. 3.7V / max. 4.2V) I2C addr: 0x6B
LiPo charger
MCU_EXTI5_LIPO
LIPO_STAT_R
LIPO_!PG_R
LIPO_OTG_R
LIPO_PSEL
LiPo: BAK_18650CA-1S-3J Max charge: 2.2A
I_INMAX = (1V / R_ILIM) * 530 = 241R
MCU_ADC1_IN8_LIPO_CUR
LIPO_VBUS
Iq=0.45uA
Abracon ASPI-6045S-2R2N-T 6.00mm x 6.00mm

Schematic: HFT-Core-Module_1V1.sch, sheet 26, ADC1/TIMCAP - Solar Power Harvesting

Parts:
C2601, C2652: 10uF; C0402
C2602: 100nF; C0402
C2603, C2605, C2653: 10nF; C0402
C2606: 4.7uF; C0402
C2682: 1F_6V_SCMR18H105MRBB0; C115-080X160_POL
D2681: CRS08; SOD80C
L2601: 22uH; WE-TPC_3MM8-3MM8_R-1MM3
L2651: 10uH; L_4.90MM_X_4.90MM
R2611: 1kR; R0402
R2612: 100kR; R0402
R2621, R2633: 1.82MR; R0402
R2622: 10.0MR; R0402
R2631: 3.65MR; R0402
R2632: 7.50MR; R0402
R2641: 4.75MR; R0402
R2642: 8.20MR; R0402
R2651, R2681: 0R; R0402
TP_BQ_VBAT: PTR1B1,27; B1,27
TP_BQ_VOUT: PTR1B1,27; B1,27
TP_BQ_VSTOR: PTR1B1,27; B1,27
TP_VSOL: PTR1B1,27; B1,27
U2601: BQ25570; V-PVQFN-20
U2681: TS5A23166; R-PDSO-G8
X2601: WIRE-TO-BOARD_5MM08_1X02

Connections:
+3V3: R2651.2; also elsewhere on the board
+5V0: R2681.2; also elsewhere on the board
BQ_LBOOST: L2601.1, R2612.2, U2601.20 (LBOOST)
BQ_LBUCK: L2651.2, U2601.16 (LBUCK)
BQ_OK_HYST: R2632.2, R2633.1, U2601.10 (OK_HYST)
BQ_OK_PROG: R2631.2, R2632.1, U2601.11 (OK_PROG)
BQ_VBAT_OV: R2621.2, R2622.1, U2601.7 (VBAT_OV)
BQ_VOUT: C2652.1, C2653.1, L2651.1, R2651.1, TP_BQ_VOUT.TP, U2601.14 (VOUT)
BQ_VOUT_SET: R2641.2, R2642.1, U2601.12 (VOUT_SET)
BQ_VRDIFF: R2622.2, R2633.2, R2642.2, U2601.8 (VRDIFF)
BQ_VREF_SAMP: C2603.2, U2601.4 (VREF_SAMP)
BQ_VSTOR: C2605.1, C2606.1, D2681.C, TP_BQ_VSTOR.TP, U2601.3 (VOC_SAMP), U2601.6 (VOUT_EN), U2601.19 (VSTOR), U2681.2, U2681.6, U2681.8
BQ_VSTOR_SW: D2681.A, R2681.1, U2681.1, U2681.5
GND: C2601.2, C2602.2, C2603.1, C2605.2, C2606.2, C2652.2, C2653.2, C2682.-, R2621.1, R2631.1, R2641.1, U2601.1 (VSS), U2601.15 (VSS), U2681.4, X2601.2; also elsewhere on the board
PA0: R2611.2; also elsewhere on the board
PE4: U2601.5 (!EN); also elsewhere on the board
PEXPB_P1_0_R: U2681.3, U2681.7; also elsewhere on the board
PF7: R2612.1; also elsewhere on the board
VBAT: C2682.+, TP_BQ_VBAT.TP, U2601.18 (VBAT)
VSOL: C2601.1, C2602.1, L2601.2, R2611.1, TP_VSOL.TP, U2601.2 (VIN_DC), X2601.1

Notes on the sheet:
WE 744031220 3.80 mm x 3.80 mm
Solar power converter --> 5.2V, 3.3V
MCU_ADC1_IN5_VSOL
MCU_TIMCAP_VSOL
Solar connector
Solar power harvesting
MURATA JELF243A-0122 4.9mm x 4.9mm
place near VOC_SAMP
V_should = 5.2V
BQ_!EN
+5V0_BQ_EN

Schematic: HFT-Core-Module_1V1.sch, sheet 27, PMIC 5V --> 3V3

Parts:
C2701: 4.7uF; C0603
C2711: 10uF; C0603
L2711: 2.2uH; L_4.50MM_X_3.20MM
R2701, R2731: 0R; R0402
R2713: 100kR; R0402
U2701: TPS62743YFPR; WCSP-8

Connections:
+3V3: R2731.2; also elsewhere on the board
+5V0: R2701.1; also elsewhere on the board
GND: C2701.2, C2711.2, U2701.2B (VSS); also elsewhere on the board
PE5: R2713.2, U2701.1B (EN); also elsewhere on the board
TPS_SW: L2711.2, L2711.4 (2), U2701.1A (SW)
TPS_VIN: C2701.1, R2701.2, R2713.1, U2701.1C (VSEL1), U2701.1D (VSEL2), U2701.2A (VIN), U2701.2D (VSEL3)
TPS_VOUT: C2711.1, L2711.1, L2711.3 (1), R2731.1, U2701.2C (VOS)

Notes on the sheet:
PMIC 5.0V --> 3.3V
PMIC 5V0 --> 3V3
TPS_EN
TOKO 1285AS-H-2R2M=P2

Schematic: HFT-Core-Module_1V1.sch, sheet 28, I2C1 - PMIC 3.3V -> 1.2V

Parts:
C2703: 10uF; C0402
C2801: 4.7uF; C0402
L2891: 2.2uH; L_4.90MM_X_4.90MM
R2801: 100kR; R0402
TP_+1V2: PTR1B1,27; B1,27
U2801: TPS62743YFPR; WCSP-8

Connections:
+1V2: C2703.1, L2891.1, TP_+1V2.TP, U2801.2C (VOS); also elsewhere on the board
+3V3: C2801.1, U2801.2A (VIN); also elsewhere on the board
GND: C2703.2, C2801.2, U2801.1C (VSEL1), U2801.1D (VSEL2), U2801.2B (VSS), U2801.2D (VSEL3); also elsewhere on the board
PEXPA_P0_4_R: R2801.1; also elsewhere on the board
VDD12_EN: R2801.2, U2801.1B (EN)
VDD12_SW: L2891.2, U2801.1A (SW)

Notes on the sheet:
PMIC 3.3V --> 1.2V
PMIC_VDD12_EN
TOKO 1285AS-H-2R2M=P2
PMIC 3V3 --> 1V2

Schematic: HFT-Core-Module_1V1.sch, sheet 29, Switch: VUSB --> LiPo charger

Parts:
C2901, C2902, C2903: 100nF; C0402
D2901, D2902: CRS08; SOD80C
R2901, R2902: 100R; R0402
R2903, R2904: 1MR; R0402
R2911: 47R; R0402
TP_VUSB_SW: PTR1B1,27; B1,27
U2901: TS5A23166; R-PDSO-G8

Connections:
GND: C2901.2, C2902.2, C2903.2, R2904.1, U2901.4; also elsewhere on the board
MCU_VBUS_SOFT_SW_EN_OUT_R: R2903.1, R2911.2, U2901.7
PEXPA_P0_0_R: R2904.2, U2901.3; also elsewhere on the board
PF5: R2911.1; also elsewhere on the board
VDDUSB: C2901.1, D2901.A, U2901.5; also elsewhere on the board
VDDUSB_DK: C2902.1, D2901.C, D2902.C, R2901.2, R2902.2, R2903.2, U2901.8
VDDUSB_SOFT: R2901.1, R2902.1, U2901.1
VUSB_SW: C2903.1, D2902.A, TP_VUSB_SW.TP, U2901.2, U2901.6; also elsewhere on the board

Notes on the sheet:
Electronic switch for USB connector activation
VBUS_HARD_SW_EN
Iq=0.01uA
MCU_VBUS_SOFT_SW_EN_OUT
(pulled down)
(pulled up)
SOFT
HARD

Schematic: HFT-Core-Module_1V1.sch, sheet 30, Switch: 3.3V -> 3.3V_XO _PA

Parts:
C3001, C3002, C3003: 100nF; C0402
TP_+3V3_XO, TP_+3V3_XO_PA: PTR1B1,27; B1,27
U3001: TS5A23166; R-PDSO-G8

Connections:
+3V3: C3001.1, U3001.1, U3001.5; also elsewhere on the board
+3V3_XO: C3003.1, TP_+3V3_XO.TP, U3001.6; also elsewhere on the board
+3V3_XO_PA: TP_+3V3_XO_PA.TP, U3001.2; also elsewhere on the board
GND: C3001.2, C3002.2, C3003.2, U3001.4; also elsewhere on the board
PEXPA_P0_1_R: U3001.3; also elsewhere on the board
PEXPA_P0_2_R: U3001.7; also elsewhere on the board
PEXPA_P1_7_R: C3002.1, U3001.8; also elsewhere on the board

Notes on the sheet:
Electronic switch for TCXO unit
SW_PWR
+3V3_XO_EN
+3V3_XO_PA_EN
Iq=0.01uA

Schematic: HFT-Core-Module_1V1.sch, sheet 31, Switch: 3.3V -> 3.3V_High-Current

Parts:
C3101, C3102, C3103: 100nF; C0402
TP_+3V3_HICUR: PTR1B1,27; B1,27
U3101: TS5A23166; R-PDSO-G8

Connections:
+3V3: C3101.1, U3101.1, U3101.5; also elsewhere on the board
+3V3_HICUR: C3103.1, TP_+3V3_HICUR.TP, U3101.2, U3101.6; also elsewhere on the board
GND: C3101.2, C3102.2, C3103.2, U3101.4; also elsewhere on the board
PEXPA_P0_3_R: U3101.3, U3101.7; also elsewhere on the board
PEXPA_P1_7_R: C3102.1, U3101.8; also elsewhere on the board

Notes on the sheet:
Electronic switch for clock distribution unit
SW_PWR
+3V3_HICUR_EN
Iq=0.01uA

Schematic: HFT-Core-Module_1V1.sch, sheet 32, Switch SMTP 1.2V -> MCU

Parts:
C3201, C3202, C3203, C3204, C3205: 100nF; C0402
TP_+1V2_MCU: PTR1B1,27; B1,27
U3201: TS5A23166; R-PDSO-G8

Connections:
+1V2: C3201.1, U3201.1, U3201.5; also elsewhere on the board
GND: C3201.2, C3202.2, C3203.2, C3204.1, C3205.2, U3201.4; also elsewhere on the board
MCU_VDD12: C3203.1, C3204.2, C3205.1, TP_+1V2_MCU.TP, U3201.2, U3201.6; also elsewhere on the board
PEXPA_P0_5_R: U3201.3, U3201.7; also elsewhere on the board
PEXPA_P1_7_R: C3202.1, U3201.8; also elsewhere on the board

Notes on the sheet:
Electronic switch for MCU SMTP ext. 1.2V
SW_PWR
MCU_VDD12_SW_EN
Iq=0.01uA

Schematic: HFT-Core-Module_1V1.sch, sheet 33, USB Jack

Parts:
C3303: 1nF; C0402
PF3311: 1.1A/2.2A; M1206
R3302: 330kR; R0402
X3301: MOLEX 105017-0001; USB-B-MICRO-SMD_MOLEX-105017-0001

Connections:
GND: C3303.1, R3302.1, X3301.GND; also elsewhere on the board
PA9: PF3311.1, X3301.VBUS (J_VUSB); also elsewhere on the board
PA10: X3301.ID (J_ID); also elsewhere on the board
PA12PA11_N: X3301.D- (J_D-); also elsewhere on the board
PA12PA11_P: X3301.D+ (J_D+); also elsewhere on the board
USB_SHIELD: C3303.2, R3302.2, X3301.JSHIELD (SHIELD), X3301.JSHIELD@2 (SHIELD), X3301.JSHIELD@3 (SHIELD), X3301.JSHIELD@4 (SHIELD), X3301.JSHIELD@5 (SHIELD), X3301.JSHIELD@6 (SHIELD)
VDDUSB: PF3311.2; also elsewhere on the board

Notes on the sheet:
Impedance 90 Ohms
USB device and USB host (OTG) interface
MCU_USB_OTG_FS_DM
MCU_USB_OTG_FS_DP
MCU_USB_OTG_FS_ID
MCU_USB_OTG_FS_VBUS
LITTLEFUSE 1206L050YR

Schematic: HFT-Core-Module_1V1.sch, sheet 34, SMA sockets

Parts:
C3471, C3472, C3481, C3482, C3491, C3492: 0pF; C0402
C3483: 0.5pF; C0402
C3485, C3489: 1.2pF; C0402
C3486: 1.8pF; C0402
C3488: 1.5pF; C0402
C3493: 100nF; C0402
L3484: 1.2nH; L0603
L3486, L3488: 4.7nH; L0603
L3487: 2.7nH; L0603
L3493: WE-CBF_300R; L3216C
R3471, R3481, R3491: 0R; R0603
RPOLY3493: 50mA/150mA; R1210
U3491: TS5A23166; R-PDSO-G8
U3492: TDK B4310; QCS5P
X3401: SMA_SMT_AMPHENOL-901-143; SMA_SMT_AMPHENOL_901-143
X3411: SAMTEC SMA-J-P-H-RA-TH1; SMA_SMT_AMPHENOL_901-143
X3471, X3481, X3491: SMA_SMT_AMPHENOL-901-143, SAMTEC SMA-J-P-H-RA-TH1; SMA_SMT_AMPHENOL_901-143

Connections:
+3V3: C3493.1, U3491.1, U3491.5; also elsewhere on the board
+3V3_GPS: RPOLY3493.1, U3491.2, U3491.6
BT_ANT: C3482.1, R3481.2, X3481.1
CH1_ANT: X3401.1; also elsewhere on the board
CH2_ANT: X3411.1; also elsewhere on the board
GND: C3471.2, C3472.2, C3481.2, C3482.2, C3483.2, C3485.2, C3486.2, C3489.2, C3491.2, C3492.2, C3493.2, L3488.2, U3491.4, U3492.2, U3492.3, U3492.5, X3401.2, X3401.3 (2), X3401.4 (2), X3401.5 (2), X3411.2, X3411.3 (2), X3411.4 (2), X3411.5 (2), X3471.2, X3471.3 (2), X3471.4 (2), X3471.5 (2), X3481.2, X3481.3 (2), X3481.4 (2), X3481.5 (2), X3491.2, X3491.3 (2), X3491.4 (2), X3491.5 (2); also elsewhere on the board
GPS_ANT: C3492.1, R3491.2, X3491.1
GPS_ANT_SAW: C3491.1, L3493.1, R3491.1, U3492.4
GPS_POLY: L3493.2, RPOLY3493.2
GSM_ANT: C3472.1, R3471.2, X3471.1
PEXPA_P1_2_R: U3491.3, U3491.7; also elsewhere on the board
PEXPA_P1_7_R: U3491.8; also elsewhere on the board
SIM_BT_ANT: C3483.1, L3484.1; also elsewhere on the board
SIM_BT_ANT_L: C3485.1, L3484.2, L3486.1, L3487.1
SIM_BT_ANT_L_L: C3481.1, C3488.1, C3489.1, L3487.2, R3481.1
SIM_BT_ANT_L_LC: C3486.1, L3486.2
SIM_BT_ANT_L_L_LC: C3488.2, L3488.1
SIM_GPS_ANT: U3492.1; also elsewhere on the board
SIM_GSM_ANT: C3471.1, R3471.1; also elsewhere on the board

Notes on the sheet:
SMA connectors
SMA channel 1
GSM
SMA channel 2
Blue Tooth
GNSS
GPS_SW_EN
SW_PWR

Schematic: HFT-Core-Module_1V1.sch, sheet 35, 3.5 mm Jack

Parts:
X3501, X3511: CUI SJ1-3535NS; SJ1-353XNS_3MM5-STEREO-AUDIO-JACKS

Connections:
AUDIO_IN_L: X3501.12 (TIP), X3501.22 (TIP); also elsewhere on the board
AUDIO_IN_R: X3501.13 (RING), X3501.23 (RING); also elsewhere on the board
AUDIO_OUT_L: X3511.12 (TIP), X3511.22 (TIP); also elsewhere on the board
AUDIO_OUT_R: X3511.13 (RING), X3511.23 (RING); also elsewhere on the board
GND: X3501.11 (SLEEVE), X3501.16 (GND), X3501.21 (SLEEVE), X3501.51, X3501.52, X3501.53, X3501.61, X3501.62, X3501.63, X3511.11 (SLEEVE), X3511.16 (GND), X3511.21 (SLEEVE), X3511.51, X3511.52, X3511.53, X3511.61, X3511.62, X3511.63; also elsewhere on the board

Notes on the sheet:
Audio connectors
AUDIO IN
AUDIO OUT
TODO: fix layout of sockets

Schematic: HFT-Core-Module_1V1.sch, sheet 36, Expansion Connectors

Parts:
R3601, R3602, R3603, R3604, R3605, R3606, R3607, R3608, R3609, R3610, R3611, R3614, R3615, R3616, R3617, R3618, R3619, R3620, R3621, R3622, R3623, R3666, R3667, R3668, R3669, R3670, R3671, R3672, R3673, R3674, R3675, R3676, R3679, R3680, R3681, R3682, R3683, R3684, R3685, R3686, R3687, R3688: 47R; R0402
R3612, R3613, R3677, R3678: 0R; R0402
X3611, X3612, X3631, X3632: 2X20/90_1MM27_HARWIN_M50-3202045_SOCKET

Connections:
+3V3: X3611.3, X3611.4, X3612.37, X3612.38, X3631.3, X3631.4, X3632.37, X3632.38; also elsewhere on the board
+5V0: X3611.37, X3611.38, X3631.37, X3631.38; also elsewhere on the board
CLK0_N: X3632.4; also elsewhere on the board
CLK0_P: X3632.3; also elsewhere on the board
CLK2_N: X3612.4; also elsewhere on the board
CLK2_P: X3612.3; also elsewhere on the board
EVT_N_OUT: R3609.2, X3611.29
EVT_S_OUT: R3674.2, X3631.29
GND: X3611.1, X3611.2, X3611.5, X3611.6, X3611.8, X3611.10, X3611.12, X3611.14, X3611.21, X3611.22, X3611.27, X3611.28, X3611.30, X3611.32, X3611.34, X3611.35, X3611.36, X3611.39, X3611.40, X3612.1, X3612.2, X3612.5, X3612.6, X3612.9, X3612.10, X3612.14, X3612.15, X3612.16, X3612.21, X3612.22, X3612.25, X3612.27, X3612.28, X3612.39, X3612.40, X3631.1, X3631.2, X3631.5, X3631.6, X3631.8, X3631.10, X3631.12, X3631.14, X3631.21, X3631.22, X3631.27, X3631.28, X3631.30, X3631.32, X3631.34, X3631.35, X3631.36, X3631.39, X3631.40, X3632.1, X3632.2, X3632.5, X3632.6, X3632.9, X3632.10, X3632.14, X3632.15, X3632.16, X3632.21, X3632.22, X3632.25, X3632.27, X3632.28, X3632.39, X3632.40; also elsewhere on the board
I2C2_SCL_N: R3612.2, X3612.7
I2C2_SCL_S: R3677.2, X3632.7
I2C2_SDA_N: R3613.2, X3612.8
I2C2_SDA_S: R3678.2, X3632.8
I2S_FS_N_IN: R3623.2, X3612.26
I2S_FS_N_OUT: R3620.2, X3612.20
I2S_FS_S_IN: R3688.2, X3632.26
I2S_FS_S_OUT: R3685.2, X3632.20
I2S_MCLK_N_OUT: R3619.2, X3612.19
I2S_MCLK_S_OUT: R3684.2, X3632.19
I2S_SCK_N_IN: R3621.2, X3612.23
I2S_SCK_N_OUT: R3617.2, X3612.17
I2S_SCK_S_IN: R3686.2, X3632.23
I2S_SCK_S_OUT: R3682.2, X3632.17
I2S_SD_N_IN: R3622.2, X3612.24
I2S_SD_N_OUT: R3618.2, X3612.18
I2S_SD_S_IN: R3687.2, X3632.24
I2S_SD_S_OUT: R3683.2, X3632.18
PB3: R3601.1; also elsewhere on the board
PB5: R3602.1; also elsewhere on the board
PB6: R3603.1; also elsewhere on the board
PB7: R3604.1; also elsewhere on the board
PB13: R3621.1, R3686.1; also elsewhere on the board
PB15: R3614.1, R3679.1; also elsewhere on the board
PC13: R3611.1, R3676.1; also elsewhere on the board
PD1: R3616.1, R3681.1; also elsewhere on the board
PD3: R3615.1, R3680.1; also elsewhere on the board
PD9: R3666.1; also elsewhere on the board
PD10: R3667.1; also elsewhere on the board
PD11: R3622.1, R3687.1; also elsewhere on the board
PD12: R3623.1, R3688.1; also elsewhere on the board
PD14: R3668.1; also elsewhere on the board
PD15: R3669.1; also elsewhere on the board
PE3: R3618.1, R3683.1; also elsewhere on the board
PE8: R3617.1, R3682.1; also elsewhere on the board
PE9: R3620.1, R3685.1; also elsewhere on the board
PE10: R3619.1, R3684.1; also elsewhere on the board
PF0: R3613.1, R3678.1; also elsewhere on the board
PF1: R3612.1, R3677.1; also elsewhere on the board
PF6: R3610.1; also elsewhere on the board
PF8: R3675.1; also elsewhere on the board
PG4: R3609.1, R3674.1; also elsewhere on the board
PG9: R3605.1, R3670.1; also elsewhere on the board
PG10: R3606.1, R3671.1; also elsewhere on the board
PG11: R3608.1, R3673.1; also elsewhere on the board
PG12: R3607.1, R3672.1; also elsewhere on the board
PN00: R3601.2, X3611.7
PN01: R3602.2, X3611.9
PN02: R3603.2, X3611.11
PN03: R3604.2, X3611.13
PS00: R3666.2, X3631.7
PS01: R3667.2, X3631.9
PS02: R3668.2, X3631.11
PS03: R3669.2, X3631.13
SPI2_MISO_N: R3615.2, X3612.12
SPI2_MISO_S: R3680.2, X3632.12
SPI2_MOSI_N: R3614.2, X3612.11
SPI2_MOSI_S: R3679.2, X3632.11
SPI2_SCK_N: R3616.2, X3612.13
SPI2_SCK_S: R3681.2, X3632.13
TIMCAP_N_IN: R3610.2, X3611.31
TIMCAP_S_IN: R3675.2, X3631.31
UART1_CTS_N_IN: R3608.2, X3611.26
UART1_CTS_S_IN: R3673.2, X3631.26
UART1_RTS_N_OUT: R3607.2, X3611.25
UART1_RTS_S_OUT: R3672.2, X3631.25
UART1_RX_N_IN: R3606.2, X3611.24
UART1_RX_S_IN: R3671.2, X3631.24
UART1_TX_N_OUT: R3605.2, X3611.23
UART1_TX_S_OUT: R3670.2, X3631.23
WAKEUP_N_IN: R3611.2, X3611.33
WAKEUP_S_IN: R3676.2, X3631.33

Notes on the sheet:
North-West
South-East
North-East
South-West
Expansion connectors

Schematic: HFT-Core-Module_1V1.sch, sheet 37, Mounting holes

Parts:
H3711, H3721, H3731: MOUNT-PAD-ROUND3.0; 3,0-PAD

Connections:
GND: H3711.B3,0, H3721.B3,0, H3731.B3,0; also elsewhere on the board

Notes on the sheet:
Mounting holes

Notices in the files:
CAD/Eagle/HFT-Core-Module_1V1.brd:
(C) 2019 by Fakultät N,
Hochschule Mannheim,
